options:
  parameters:
    author: andyk
    generate_options: no_gui
    id: demod_am_from_wav
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '10000'
    gain: samp_rate/10000
    samp_rate: samp_rate
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '.5'
    decay_rate: '1e-5'
    gain: '1'
    max_gain: '10000'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '3'
    audio_pass: '8000'
    audio_stop: '10000'
    chan_rate: samp_rate/100
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    type: complex
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters: {}
  states: {}
- name: analog_standard_squelch_0
  id: analog_standard_squelch
  parameters:
    audio_rate: '8000'
    threshold: squelch
  states: {state: disabled}
- name: analog_standard_squelch_1
  id: analog_standard_squelch
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_gain
    type: float
  states: {state: disabled}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\gnuradiofiles\test1.wav
    format: FORMAT_WAV
    samp_rate: '8000'
  states: {state: disabled}
- name: blocks_wavfile_sink_0_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: input_filename.replace(".wav","_audio.wav")
    format: FORMAT_WAV
    samp_rate: '8000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: '"" +str(input_filename)'
    nchan: '2'
    repeat: 'False'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: dc_blocker_xx_0_1
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset_freq_khz
    decim: '10'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: input_filename
  id: parameter
  parameters:
    type: str
    value: '"1707684526.wav"'
  states: {}
- name: offset_freq_khz
  id: parameter
  parameters:
    type: intx
    value: '400000'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '30'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '2400000'
  states: {}

connections:
- [analog_agc2_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [analog_standard_squelch_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0_1, '0']
- [blocks_float_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [dc_blocker_xx_0, '0', analog_standard_squelch_0, '0']
- [dc_blocker_xx_0_0, '0', analog_agc2_xx_0, '0']
- [dc_blocker_xx_0_1, '0', blocks_wavfile_sink_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', dc_blocker_xx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
